# Keil uVision project Flash.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F582 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: Flash
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Lib\Inc
  group Src
    ./: STARTUP.A51 L51_BANK.A51
    ../User/: main.c
    ../User/Lib/Src/: F580_FlashPrimitives.c F580_FlashUtils.c
