# Keil uVision project my_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F582 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: my_project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Header_File
    ./: timer.h gpio.h exti.h compiler_defs.h clock.h C8051F580_defs.h
  group Source_File
    ./: clock.c exti.c gpio.c main.c timer.c
