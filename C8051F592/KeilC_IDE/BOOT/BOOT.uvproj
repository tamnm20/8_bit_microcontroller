# Keil uVision project BOOT.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F580 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    C:/Silabs/MCU/Examples/C8051F58x_59x/Blinky_Banked/Keil/: L51_BANK.A51
