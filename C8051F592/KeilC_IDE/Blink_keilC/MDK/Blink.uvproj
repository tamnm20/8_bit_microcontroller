# Keil uVision project Blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F582 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: Blink +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Lib\Inc
  group Source Group 1
    ./: STARTUP.A51
    ../User/: main.c
